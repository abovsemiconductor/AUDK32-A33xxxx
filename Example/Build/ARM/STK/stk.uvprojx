# Keil uVision project stk.uvprojx, settings and files
target A33G52x (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: stk
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: EXTRN_SUBFAMILY_A33G52x EXTRN_ABOV_EXAMPLE_CONFIG
  c include: ..\..\..\..\Framework\CMSIS\Core\Include;..\..\..\..\Framework\CMSIS\Device\ABOV\Include;..\..\..\..\ProductConfig\Config;..\..\..\..\Platform\HAL\Include;..\..\..\..\Platform\HAL\HPL\Include;..\..\..\..\Platform\Library\ABOV\Debug\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x60000
  memory RVCT9: RAM 0x20000000 size 0x60000
  scatter file: ..\..\..\..\Framework\CMSIS\Device\ABOV\Source\ARM\ac5_a33xxxx.sct
  group Config
    ../../../../ProductConfig/Config/: abov_config.h abov_example_config.h
  group Main
    ../../../Source/GpioLedBlinking/: gpio_led_blinking.c
  group Startup
    ../../../../Framework/CMSIS/Device/ABOV/Source/: startup_a33xxxx.c
  group System
    ../../../../Framework/CMSIS/Device/ABOV/Source/: system_a33xxxx.c
  group HAL
    ../../../../Platform/HAL/SCU/: hal_scu.c hal_scu_clk.c
    ../../../../Platform/HAL/PCU/: hal_pcu.c
    ../../../../Platform/HAL/UART/: hal_uart.c
    ../../../../Platform/HAL/HPL/DMA/: hpl_dma.c
    ../../../../Platform/HAL/HPL/NMI/: hpl_nmi.c
  group Debug
    ../../../../Platform/Library/ABOV/Debug/Source/: debug.c debug_cmd.c debug_hardfault.c debug_log.c debug_retarget.c debug_serial.c
  group Linker_AC5
    ../../../../Framework/CMSIS/Device/ABOV/Source/ARM/: ac5_a33xxxx.sct
  group Linker_AC6
    ../../../../Framework/CMSIS/Device/ABOV/Source/ARM/: ac6_a33xxxx.sct
target A33M11x (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.8.0
  cpu: as above
  output: stk
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: EXTRN_SUBFAMILY_A33M11x EXTRN_ABOV_EXAMPLE_CONFIG
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: as above
target A33G53x (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.8.0
  cpu: as above
  output: stk
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: EXTRN_SUBFAMILY_A33G53x EXTRN_ABOV_EXAMPLE_CONFIG
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x60000
  memory RVCT9: RAM 0x20000000 size 0x60000
  scatter file: as above
