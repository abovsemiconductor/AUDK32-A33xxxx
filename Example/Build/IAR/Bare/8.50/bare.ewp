# IAR project bare.ewp, settings and files
configuration A33G52x (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: EXTRN_SUBFAMILY_A33G52x; EXTRN_ABOV_EXAMPLE_CONFIG
  ICCARM.IExtraOptions: --diag_suppress Ta023
  ICCARM.CCIncludePath2: ..\..\..\..\..\ProductConfig\Config; ..\..\..\..\..\Platform\HAL\Include; ..\..\..\..\..\Platform\HAL\HPL\Include; ..\..\..\..\..\Example\Source\Bare\Peripheral\Include; ..\..\..\..\..\Platform\Library\ABOV\Debug\Include; ..\..\..\..\..\Framework\CMSIS\Core\Include; ..\..\..\..\..\Framework\CMSIS\Device\ABOV\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: bare.srec
  ILINK.IlinkOutputFile: bare.out
  ILINK.IlinkIcfFile: ..\..\..\..\..\Framework\CMSIS\Device\ABOV\Source\IAR\a33xxxx.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration A33M11x (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: EXTRN_SUBFAMILY_A33M11x; EXTRN_ABOV_EXAMPLE_CONFIG
configuration A33G53x (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: EXTRN_SUBFAMILY_A33G53x; EXTRN_ABOV_EXAMPLE_CONFIG
  group Config
    ../../../../../ProductConfig/Config/: abov_config.h abov_example_config.h
  group Debug
    ../../../../../Platform/Library/ABOV/Debug/Source/: debug.c debug_cmd.c debug_hardfault.c debug_log.c debug_retarget.c debug_serial.c
  group Example
    ../../../../Source/Bare/Peripheral/ADC/: adc.c
    ../../../../Source/Bare/Peripheral/AFE/: afe.c
    ../../../../Source/Bare/Peripheral/CRC/: crc.c
    ../../../../Source/Bare/Peripheral/Flash/: flash.c
    ../../../../Source/Bare/Peripheral/FRT/: frt.c
    ../../../../Source/Bare/Peripheral/I2C/: i2c.c
    ../../../../Source/Bare/Peripheral/MPWM/: mpwm.c
    ../../../../Source/Bare/Peripheral/PCU/: pcu.c
    ../../../../Source/Bare/Peripheral/PWM/: pwm.c
    ../../../../Source/Bare/Peripheral/QEI/: qei.c
    ../../../../Source/Bare/Peripheral/SCU/: scu.c scu_clk.c scu_lvd.c scu_pwr.c
    ../../../../Source/Bare/Peripheral/SPI/: spi.c
    ../../../../Source/Bare/Peripheral/Timer1/: timer1.c
    ../../../../Source/Bare/Peripheral/UART/: uart.c
    ../../../../Source/Bare/Peripheral/WDT/: wdt.c
  group HAL
    ../../../../../Platform/HAL/ADC/: hal_adc.c
    ../../../../../Platform/HAL/AFE/: hal_afe.c
    ../../../../../Platform/HAL/CRC/: hal_crc.c
    ../../../../../Platform/HAL/FMC/: hal_fmc.c
    ../../../../../Platform/HAL/FRT/: hal_frt.c
    ../../../../../Platform/HAL/I2C/: hal_i2c.c
    ../../../../../Platform/HAL/MPWM/: hal_mpwm.c
    ../../../../../Platform/HAL/PCU/: hal_pcu.c
    ../../../../../Platform/HAL/PWM/: hal_pwm.c
    ../../../../../Platform/HAL/QEI/: hal_qei.c
    ../../../../../Platform/HAL/SCU/: hal_scu.c hal_scu_clk.c hal_scu_lvd.c hal_scu_pwr.c
    ../../../../../Platform/HAL/SPI/: hal_spi.c
    ../../../../../Platform/HAL/Timer1/: hal_timer1.c
    ../../../../../Platform/HAL/UART/: hal_uart.c
    ../../../../../Platform/HAL/WDT/: hal_wdt.c
    ../../../../../Platform/HAL/HPL/DMA/: hpl_dma.c
    ../../../../../Platform/HAL/HPL/NMI/: hpl_nmi.c
  group Main
    ../../../../Source/Bare/Peripheral/Main/: ex_common.c ex_peripheral.c
  group Startup
    ../../../../../Framework/CMSIS/Device/ABOV/Source/: startup_a33xxxx.c
  group System
    ../../../../../Framework/CMSIS/Device/ABOV/Source/: system_a33xxxx.c
