# IAR project stk.ewp, settings and files
configuration A33M11x (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: EXTRN_SUBFAMILY_A33M11x; EXTRN_ABOV_EXAMPLE_CONFIG
  ICCARM.CCIncludePath2: ..\..\..\..\..\ProductConfig\Config; ..\..\..\..\..\Platform\HAL\Include; ..\..\..\..\..\Platform\HAL\HPL\Include; ..\..\..\..\..\Platform\Library\ABOV\Debug\Include; ..\..\..\..\..\Framework\CMSIS\Core\Include; ..\..\..\..\..\Framework\CMSIS\Device\ABOV\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: stk.srec
  ILINK.IlinkOutputFile: stk.out
  ILINK.IlinkIcfFile: ..\..\..\..\..\Framework\CMSIS\Device\ABOV\Source\IAR\a33xxxx.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration A33G52x (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: EXTRN_SUBFAMILY_A33G52x; EXTRN_ABOV_EXAMPLE_CONFIG
configuration A33G53x (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: EXTRN_SUBFAMILY_A33G53x; EXTRN_ABOV_EXAMPLE_CONFIG
  group Config
    ../../../../../ProductConfig/Config/: abov_config.h abov_example_config.h
  group Debug
    ../../../../../Platform/Library/ABOV/Debug/Source/: debug.c debug_cmd.c debug_hardfault.c debug_log.c debug_retarget.c debug_serial.c
  group HAL
    ../../../../../Platform/HAL/PCU/: hal_pcu.c
    ../../../../../Platform/HAL/SCU/: hal_scu.c hal_scu_clk.c
    ../../../../../Platform/HAL/UART/: hal_uart.c
    ../../../../../Platform/HAL/HPL/DMA/: hpl_dma.c
    ../../../../../Platform/HAL/HPL/NMI/: hpl_nmi.c
  group Main
    ../../../../Source/GpioLedBlinking/: gpio_led_blinking.c
  group Startup
    ../../../../../Framework/CMSIS/Device/ABOV/Source/: startup_a33xxxx.c
  group System
    ../../../../../Framework/CMSIS/Device/ABOV/Source/: system_a33xxxx.c
