# IAR project tmpl_userapp.ewp, settings and files
configuration A33G52x (ARM)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: EXTRN_SUBFAMILY_A33G52x; EXTRN_ABOV_MODULE_CONFIG
  ICCARM.CCIncludePath2: ..\..\..\..\..\ProductConfig\Config; ..\..\..\..\..\Platform\HAL\Include; ..\..\..\..\..\Platform\HAL\HPL\Include; ..\..\..\..\..\Platform\Library\ABOV\Debug\Include; ..\..\..\..\..\Framework\CMSIS\Core\Include; ..\..\..\..\..\Framework\CMSIS\Device\ABOV\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: tmpl_userapp.out
  ILINK.IlinkIcfFile: ..\..\..\..\..\Framework\CMSIS\Device\ABOV\Source\IAR\a33xxxx.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration A33M11x (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: EXTRN_SUBFAMILY_A33M11x; EXTRN_ABOV_MODULE_CONFIG
  OBJCOPY.OOCOutputFile: tmpl_userapp.srec
configuration A33G53x (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: EXTRN_SUBFAMILY_A33G53x; EXTRN_ABOV_MODULE_CONFIG
  OBJCOPY.OOCOutputFile: tmpl_userapp.srec
  group Config
    ../../../../../ProductConfig/Config/: abov_config.h abov_module_config.h
  group Config/Debug
    ../../../../../Platform/Library/ABOV/Debug/Source/: debug.c debug_cmd.c debug_hardfault.c debug_log.c debug_retarget.c debug_serial.c
  group HAL
    ../../../../../Platform/HAL/ADC/: hal_adc.c
    ../../../../../Platform/HAL/AFE/: hal_afe.c
    ../../../../../Platform/HAL/CRC/: hal_crc.c
    ../../../../../Platform/HAL/FMC/: hal_fmc.c
    ../../../../../Platform/HAL/FRT/: hal_frt.c
    ../../../../../Platform/HAL/I2C/: hal_i2c.c
    ../../../../../Platform/HAL/MPWM/: hal_mpwm.c
    ../../../../../Platform/HAL/PCU/: hal_pcu.c
    ../../../../../Platform/HAL/PWM/: hal_pwm.c
    ../../../../../Platform/HAL/QEI/: hal_qei.c
    ../../../../../Platform/HAL/SCU/: hal_scu.c hal_scu_clk.c hal_scu_lvd.c hal_scu_pwr.c
    ../../../../../Platform/HAL/SPI/: hal_spi.c
    ../../../../../Platform/HAL/Timer1/: hal_timer1.c
    ../../../../../Platform/HAL/UART/: hal_uart.c
    ../../../../../Platform/HAL/WDT/: hal_wdt.c
    ../../../../../Platform/HAL/HPL/DMA/: hpl_dma.c
    ../../../../../Platform/HAL/HPL/NMI/: hpl_nmi.c
  group Main
    ../../../../Source/TmplUserApp/: main.c prv_scu_clk.c
  group Startup
    ../../../../../Framework/CMSIS/Device/ABOV/Source/: startup_a33xxxx.c
  group System
    ../../../../../Framework/CMSIS/Device/ABOV/Source/: system_a33xxxx.c
